# Keil uVision project project.uvprojx, settings and files
target rt-thread_stm32f4xx (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-stm32f4xx
  AfterMake: fromelf --bin !L --output est.bin
  AfterMake: .\filecrc.exe est.bin
  c flags: Optim=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\applications;..\drivers;..\Libraries\finsh;..\Libraries\cortex-m4;..\Libraries\common;..\include;..\include\drivers\include\drivers;..\drivers;..\include\dfs;..\include\dfs\src;..\include\drivers\spi;..\include\dfs\elmfat;..\lwip-1.4.1\src\include;..\lwip-1.4.1\src\include\ipv4;..\lwip-1.4.1\src\arch\include;..\lwip-1.4.1\src\arch;..\lwip-1.4.1\src;..\sub-G;..\ymodem;.\src;..\include\drivers\include;..\include\drivers\usb\usbhost\bare\inc;..\fafs\inc;..\lwip-1.4.1\src\include\lwip;..\include\drivers\wifi\CC3100\include;..\modbusTcp
  asm include: .\applications
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0xf8000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\rtthread-stm32f4xx.sct
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Applications
    ../applications/: canapp.c cpuusage.c dictionary.c drv_spi.c filefun.c LM73_i2c.c modbus_m.c monitor.c romfs.c startup.c upload.c wwdg.c application.c flash_if.c check.c setpool.c var_mq.c
    ./src/: Abox_log.c
  group Drivers
    ../drivers/: board.c drv_hwtimer.c gpio.c stm32f4_rtc.c stm32f4xx_eth.c stm32f4xx_it.c usart.c
  group STM32_StdPeriph
    ../system/: startup_stm32f4xx.s system_stm32f4xx.c
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Kernel
    ../Libraries/kernel/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c module.h object.c scheduler.c slab.c thread.c timer.c
  group common
    ../Libraries/common/: backtrace.c context_rvds.S cpuport.c div0.c showmem.c
  group ymodem
    ../ymodem/: tofile.c ymodem.c
  group eth
    ../lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
    ./src/: client.c
    ../lwip-1.4.1/src/arch/: sys_arch.c
    ../include/drivers/eth/: eth.c
    ../lwip-1.4.1/src/ping/: ping.c
  group subg_Abox
    ../sub-G/: si4463.c sub_G_init.c exchange.c
    ./src/: Abox_exchange.c sub_G_A.c adc.c ctrl.c flash_control.c
  group finish
    ../applications/: my_cmd.c
    ../Libraries/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_file.c shell.c symbol.c
    ./src/: telnet.c
  group file_system
    ../include/dfs/: dfs_posix.c dfs.c dfs_file.c dfs_fs.c
  group in_drivers
    ../include/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../include/drivers/misc/: pin.c
    ../include/drivers/rtc/: alarm.c rtc.c
    ../include/drivers/spi/: spi_core.c spi_dev.c
    ../include/drivers/serial/: serial.c
    ../include/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
  group usbDisk
    ../include/drivers/usb/usbhost/bare/src/: usb_hcd.c usb_hcd_int.c usbh_hcs.c usbh_ioreq.c usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c usb_bsp.c usbh_usr.c usbh_core.c usb_core.c usbh_stdreq.c
    ../include/drivers/usb/usbhost/core/: drv_usbh.c
  group fafs
    ../fafs/src/: diskio.c exfuns.c fattester.c ff.c mycc936.c
  group CC3100
    ../include/drivers/wifi/CC3100/source/: flowcont.c fs.c netapp.c netcfg.c nonos.c socket.c spawn.c wifi_board.c wifi_device.c wifi_driver.c wifi_spi.c wlan.c cc3100.c timer_tick.c
  group mqtt
    ../mqtt/mymqtt-master/MQTTClient-C/: mqtt_client.c
    ../mqtt/mymqtt-master/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    ../mqtt/mymqtt-master/tests/: mqtt_test.c
  group mbedtls
    ../mbedtls/ports/src/: aes_alt.c arc4_alt.c des_alt.c md5_alt.c rsa_alt.c sha1_alt.c sha256_alt.c sha512_alt.c timing_alt.c tls_certificate.c tls_client.c tls_hardware.c tls_net.c
    ../mbedtls/samples/: tls_app_test.c
    ../mbedtls/mbedtls/library/: ctr_drbg.c entropy.c ssl_tls.c aes.c x509_crt.c cipher.c sha512.c md5.c pk.c sha256.c gcm.c ccm.c dhm.c ecdh.c md.c oid.c ecp.c entropy_poll.c bignum.c sha1.c ssl_ciphersuites.c ssl_cli.c ssl_srv.c asn1parse.c pem.c pkparse.c x509.c cipher_wrap.c ecdsa.c pk_wrap.c rsa.c md_wrap.c ripemd160.c base64.c camellia.c blowfish.c des.c pkcs5.c pkcs12.c ecp_curves.c certs.c arc4.c asn1write.c hmac_drbg.c rsa_internal.c
  group modbusServer
    ../modbusTcp/: modbusTcpServer.c
